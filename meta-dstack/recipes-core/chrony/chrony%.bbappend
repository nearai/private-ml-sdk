FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

DEPENDS += "gnutls"
