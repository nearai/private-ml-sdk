# Update pahole to 1.29 for BTF reproducible build
SRCREV = "b9cc7963051b2099795129450f9b70c81950d02f"
